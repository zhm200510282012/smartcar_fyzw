# Keil uVision project smartcar_fyzw.uvproj, settings and files
target AI8051U_FYZW_SAFE (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: smartcar_fyzw +hex
  link misc: REMOVEUNUSED
  group App
    ../App/: main.c app_scheduler.c app_output_arbitration.c app_state_machine.c app_safety.c app_telemetry.c app_params.c app_config.h app_types.h
  group BSP
    ../BSP/: bsp_init.c bsp_timebase.c bsp_drive.c bsp_steering.c bsp_suction.c bsp_encoder.c bsp_emag.c bsp_imu.c bsp_power.c bsp_ui.c bsp_debug_uart.c board_map.h
  group Control
    ../Control/: ctrl_signal.c ctrl_line.c ctrl_attitude.c ctrl_speed.c ctrl_steering.c ctrl_vehicle.c ctrl_adhesion.c ctrl_transition.c ctrl_profile.c
  group Track
    ../Track/: track_features.c track_surface_state.c track_state_machine.c track_strategy.c
  group Official_Driver_Libs
    ../Drivers/Official_LQ/Driver/: AI8051U_32_MDU32.LIB
  group Official_Driver_Core
    ../Drivers/Official_LQ/Driver/Src/: AI8051U_ADC.c AI8051U_Clock.c AI8051U_Delay.c AI8051U_DMA.c AI8051U_GPIO.c AI8051U_I2C.c AI8051U_NVIC.c AI8051U_PWM.c AI8051U_SPI.c AI8051U_Timer.c AI8051U_UART.c AI8051U_WDT.c
  group Docs
    ../Docs/: BUILD_REPORT.md
